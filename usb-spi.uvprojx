# Keil uVision project usb-spi.uvprojx, settings and files
target usb-spi (6160000::V6.16::ARMCLANG)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usb-spi
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\test;.\LIBS;.\USB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: main.c
  group Interrupts
    ./: MDR32F9Qx_it.h MDR32F9Qx_it.c
  group Inc
    ./: MDR32F9Qx_board.h
  group USB
    ./USB/: usb_handler.c usb_setup.c usb_setup.h
  group SERVICE
    ./LIBS/: service.c service.h queue.c queue.h
  group GPIO
    ./LIBS/: gpio.c gpio.h
  group SPI
    ./LIBS/: spi.c spi.h
  group UART
    ./LIBS/: uart.c uart.h
software components: CMSIS Driver:USB Device:Custom 1.0.0, CMSIS:CORE 5.4.0, Device:Startup 1.5, Drivers:BKP 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:UART 1.5, Drivers:USB Library 1.5, Drivers:USB 1.5
